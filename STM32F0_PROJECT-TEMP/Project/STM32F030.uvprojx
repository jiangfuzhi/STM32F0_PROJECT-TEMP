# Keil uVision project STM32F030.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group CMSIS
    ../Libraries/CMSIS/Include/: core_cm0.h
  group FWLB
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ../User/: main.c stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h main.h system_stm32f0xx.c
